# Keil uVision project car.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: car
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\CMSIS;.\HARDWARE
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./user/: main.c
  group cmsis
    ./CMSIS/: system_stm32f10x.c
  group startup
    ./STARTUP/: startup_stm32f10x_md.s
  group hardware
    ./HARDWARE/: USART.c USART.h TIM3.c TIM3.h PWM.c PWM.h ENCODER.c ENCODER.h I2C2.c I2C2.h MPU6050.c MPU6050.h MOTOR.c MOTOR.h TIM1.c TIM1.h
